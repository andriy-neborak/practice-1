<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Four_in_a_row.ewp</path>
  </project>
  <batchBuild />
</workspace>
